# Keil uVision project kernel.uvprojx, settings and files
target Kernel (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Kernel +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_ENABLE_LED_INTERFACE=1, UVISION_PROJECT
  c include: ..\..\..\Include;..\..\..\Include\BSP;..\..\..\Include\Kernel;..\..\..\BSP;..\..\..\BSP\CPU\LPC1768\internal;..\..\..\Kernel;..\..\..\Kernel\Scheduler;..\..\..\Environment\Tools\Debug;..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --symdefs=../symbols/kernel_symbols --keep=OS_Yield
  group Driver + HAL
    ../../../BSP/CPU/LPC1768/internal/: system_LPC17xx.c
    ../../../BSP/CPU/LPC1768/: Drv_CPUCore.c Drv_CPUCore_Assembly.c Drv_GPIO.c Drv_Timer.c Drv_CPUCore_ExcManagement.c
    ../../../BSP/Board/LandTiger/: Drv_LED.c
    ../Config/: startup_LPC17xx.s
  group OS
    ../../../Kernel/: Kernel.c Kernel_Internal.h
    ../../../Kernel/Scheduler/: Scheduler.h
    ../../../Kernel/Scheduler/Cooparative/: CooparativeScheduler.c
    ../Config/: OSConfig.h
    ../../../Include/Kernel/: Kernel.h
  group Lib
    ../../../Environment/Tools/Debug/: Debug.c
