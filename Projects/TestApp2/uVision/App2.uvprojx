# Keil uVision project App2.uvprojx, settings and files
target TestApp2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\BSP\CPU\LPC1768\internal;..\..\..\BSP\Board\LandTiger;..\..\..\BSP\CPU\LPC1768;..\..\..\Include;..\..\..\Include\BSP;..\..\..\Include\Kernel;..\..\..\Bootloader;..\config;..\..\..\Environment\Tools\Debug
  library: MicroLIB
  memory RVCT4: ROM 0x20200 size 0x8000
  memory RVCT9: RAM 0x10005000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Driver + HAL
    ../../../BSP/Board/LandTiger/: Drv_LED.c
    ../../../BSP/CPU/LPC1768/: Drv_GPIO.c
    ../config/: startup_LPC17xx.s
  group App
    ../: main.c
  group Kernel
    ../../../Include/Kernel/: Kernel.h
    ../../kernel/symbols/: kernel_symbols
