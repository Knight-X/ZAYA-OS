# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\config;..\..\config\mbedtls;..\..\..\..\Include;..\..\..\..\Include\BSP;..\..\..\..\BSP\CPU\LPC1768;..\..\..\..\BSP\CPU\LPC1768\internal;..\..\..\..\Environment\Lib\IntelHex;..\..\..\..\Environment\ExternalLib\mbedTLS\include;..\..\..\..\Environment\ExternalLib\mbedTLS\include\mbedtls;..\..\..\..\Environment\Tools\Debug;..\..\..\..\Bootloader\TestData
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Bootloader
    ../../../../Bootloader/: Bootloader.c Bootloader_Security.c Bootloader_Internal.h Bootloader_Upgrade.c
    ../../../Bootloader/Config/: Bootloader_Config.h
    ../../../../Bootloader/TestData/: TestData.h
  group Driver + HAL
    ../../../../BSP/CPU/LPC1768/: Drv_CPUCore.c Drv_CPUCore_Assembly.c Drv_Timer.c Drv_UART.c Drv_Flash.c
    ../../../../BSP/CPU/LPC1768/internal/: system_LPC17xx.c
    ../../config/: startup_LPC17xx.s
  group ExternalLib
    ../../../../Environment/ExternalLib/mbedTLS/library/: asn1parse.c bignum.c md.c md_wrap.c md5.c oid.c platform.c ripemd160.c rsa.c sha1.c sha256.c memory_buffer_alloc.c
  group Lib
    ../../../../Environment/Lib/IntelHex/: IntelHex.c
