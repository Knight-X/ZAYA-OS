# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\Include\BSP;..\..\..\BSP\CPU\LPC1768;..\..\..\BSP\CPU\LPC1768\internal;..\..\..\Bootloader\Config;..\..\..\Environment\Tools\Debug;.\Config
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Bootloader
    ../../../Bootloader/: Bootloader.c
  group Driver + HAL
    ../../../BSP/CPU/LPC1768/: Drv_CPUCore.c Drv_CPUCore_Assembly.c Drv_Timer.c
    ../../../BSP/CPU/LPC1768/internal/: startup_LPC17xx.s system_LPC17xx.c
